# Repository pulsarfab/pulsarfab (continued)

## KiCad design hardware/pulsardew/pulsardew.kicad_pcb (continued)

Board: 2 copper layers, 62 parts (0 on the bottom side), 32 nets, no tracks yet.

Other parts of the board:
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3

File hardware/pulsardew/jlcpcb_bom.csv:

"Item","Designator","Comment","Footprint","Qty","LCSC Part #","MPN","Manufacturer"
"1","C1,C2,C30,C40","100n","Capacitor_SMD:C_0402_1005Metric","4","","",""
"2","C3","4.7u / 10V","Capacitor_SMD:C_0402_1005Metric","1","","",""
"3","C10","470u/25V","Capacitor_SMD:CP_Elec_8x10.5","1","","",""
"4","C20","10u / 50V","Capacitor_SMD:C_1210_3225Metric","1","","",""
"5","C21","10u / 10V","Capacitor_SMD:C_0805_2012Metric","1","","",""
"6","C22","100n / 50V","Capacitor_SMD:C_0603_1608Metric","1","","",""
"7","C23","100n / 10V","Capacitor_SMD:C_0402_1005Metric","1","","",""
"8","D10","SS54","Diode_SMD:D_SMA_Handsoldering","1","C22452","SS54",""
"9","D101,D201,D301,D401","BZT52C12 12V","Diode_SMD:D_SOD-123","4","C19077410","BZT52C12",""
"10","D102,D202,D302,D402","SMBJ20A","Diode_SMD:D_SMB_Handsoldering","4","C364296","SMBJ20A",""
"11","J1","USB-C","pulsarfab:USB_C_HRO_TYPE-C-31-M-12","1","C165948","TYPE-C-31-M-12","Korean Hroparts Elec"
"12","J2","XKB DC-005K / 5A","pulsarfab:BarrelJack_XKB_DC-005K-5A_Edge","1","C2880546","DC-005K-5A-2.0","XKB Connection"
"13","J3","Phoenix 2-pos","TerminalBlock_Phoenix:TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizontal","1","","",""
"14","J4","SWD","Connector_PinHeader_2.54mm:PinHeader_1x05_P2.54mm_Vertical","1","","",""
"15","J101,J201,J301,J401","HEATER","TerminalBlock_Phoenix:TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizontal","4","","",""
"16","Q101,Q201,Q301,Q401","2N7002","Package_TO_SOT_SMD:SOT-23","4","C8545","2N7002",""
"17","Q102,Q202,Q302,Q402","AOD4184A","Package_TO_SOT_SMD:TO-252-2","4","C5370959","AOD4184A",""
"18","R10,R11","5.1k","Resistor_SMD:R_0402_1005Metric","2","","",""
"19","R12,R13,R101,R201,R301,R401","100k","Resistor_SMD:R_0402_1005Metric","6","","",""
"20","R20,R21","4.7k","Resistor_SMD:R_0402_1005Metric","2","","",""
"21","R30","2m","Resistor_SMD:R_2512_6332Metric","1","C459679","RLP25FEGR002",""
"22","R102,R202,R302,R402","10k","Resistor_SMD:R_0402_1005Metric","4","","",""
"23","R103,R203,R303,R403","47","Resistor_SMD:R_0402_1005Metric","4","","",""
"24","U1","STM32G0B1KBU6","Package_DFN_QFN:UFQFPN-32-1EP_5x5mm_P0.5mm_EP3.5x3.5mm","1","C5159549","STM32G0B1KBU6",""
"25","U2","HT7333-1","Package_TO_SOT_SMD:SOT-89-3","1","","HT7333-1","Holtek"
"26","U3","INA226","Package_SO:TSSOP-10_3x3mm_P0.5mm","1","C49851","INA226AIDGSR",""
"27","U4","SHT40-AD1B","Sensor_Humidity:Sensirion_DFN-4_1.5x1.5mm_P0.8mm_SHT4x_NoCentralPad","1","C2909890","SHT40-AD1B-R2",""
